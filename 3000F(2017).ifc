Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-20T11:03:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 20 11:03:00 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{DEB6B9F1-4169-4EC4-A605-B840CB9F858F}\ifc * Database version: 5507 * Database creation date: Wed Jun 20 11:02:59 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 20 11:03:00 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 20 11:03:00 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 3000F Washbasin faucet, 3000F(2017):3000F Washbasin faucet:342469
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 174 mm; NominalHeight: 169.5 mm; NominalWidth: 49 mm; Projection: 119 mm
Type - General - Author: Convergo AB; BIMObjectName: 3000F(2017); ConvergoRefNr: 0087-1806-0096-FI; ExpiringDate: 12/2018; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 15/06/2018
Type - Green Building Properties - EAN Number: 6414150082580; EN Standard: EN 817; Noise Class: I (ISO 3822)
Type - Identity Data - Class: Single lever; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 3000F Washbasin faucet; Name_en: 3000F Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 3000F; Product Family: Oras Inspera; Type Name: 3000F Washbasin faucet
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Flow Rate At 300kPa: 0.0105944 m3/s; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 150000 Pa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3000F(2017); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3000F; Name: 3000F Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x175x170 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3000F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3000F Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.0474231 m2; Volume: 0.00144983 m3
Identity Data - Mark: 21
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 3000F(2017): 3000F Washbasin faucet; Family and Type: 3000F(2017): 3000F Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3000F(2017): 3000F Washbasin faucet; Type Id: 3000F(2017): 3000F Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
